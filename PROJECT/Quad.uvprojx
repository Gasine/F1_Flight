# Keil uVision project Quad.uvprojx, settings and files
target Quad (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Quad +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\SYSTEM;..\MAIN;..\STM32F10x_Lib\inc;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\MPU6050;..\HARDWARE\IIC;..\HARDWARE\HMC5883L;..\HARDWARE\TIMER;..\HARDWARE\Interrupt;..\HARDWARE\Motor;..\HARDWARE\Ultrasonic;..\HARDWARE\HC05;..\Algorithm\math;..\Algorithm\AHRS;..\Algorithm\filter;..\Algorithm\quaternion;..\FUNCTION\control;..\FUNCTION\ultracontrol;..\HARDWARE\STMFLASH
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group MAIN
    ../MAIN/: main.c include.h Para.h
  group HARDWARE
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/OLED/: OLED.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/HMC5883L/: hmc5883.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/Interrupt/: stm32it.c
    ../HARDWARE/Motor/: motor.c
    ../HARDWARE/Ultrasonic/: Ultrasonic.c
    ../HARDWARE/HC05/: hc05.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group SYSTEM
    ../SYSTEM/: startup_stm32f10x_hd.s sys.c stm32f10x_it.c system_stm32f10x.c core_cm3.c
  group ST_LIB
    ../STM32F10x_Lib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_flash.c
  group ALGORITHM
    ../Algorithm/math/: Algorithm_math.c
    ../Algorithm/AHRS/: ahrs.c
    ../Algorithm/filter/: filter.c
    ../Algorithm/quaternion/: Algorithm_quaternion.c
  group FUNCTION
    ../FUNCTION/control/: control.c
    ../FUNCTION/ultracontrol/: ultracontrol.c
